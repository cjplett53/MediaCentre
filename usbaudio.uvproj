# Keil uVision project usbaudio.uvproj, settings and files
target Flash (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: LPC1768 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10007FFF) IRAM2(0x2007C000-0x20083FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: usbaudio +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c include: .\common\inc;.\common\src
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x4000
  scatter file: .\DMA.sct
  group Audio
    ./: usbuser.c usbcore.c usbdesc.c usbdmain.c usbhw.c adcuser.c usbdmain.h
  group Startup Files
    ./: system_LPC17xx.c core_cm3.c startup_LPC17xx.s
  group Main Group
    ./: main.c main.h GLCD.h KBD.h LED.h KBD.c LED.c GLCD_SPI_LPC1700.c
  group Photo Gallery
    ./: gallery.c polarbear.c seal1.c seal2.c gallery.h
  group Game Center
    ./: game.h bankRobberGT.h bankRobberGT.c game.c
